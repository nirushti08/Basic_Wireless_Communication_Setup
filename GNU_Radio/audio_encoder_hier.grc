options:
  parameters:
    generate_options: hb
    id: audio_encoder
    output_language: python
    title: Audio Encoder Hier
  states: {}

blocks:
- name: scale
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: scale
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: byte
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: audio_in_0
    type: float
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: audio_in_1
    type: float
  states: {}
- name: vocoder_ulaw_encode_sb_0
  id: vocoder_ulaw_encode_sb
  parameters: {}
  states: {}

connections:
- [blocks_float_to_short_0, '0', vocoder_ulaw_encode_sb_0, '0']
- [blocks_stream_mux_0, '0', blocks_float_to_short_0, '0']
- [pad_source_0, '0', blocks_stream_mux_0, '0']
- [pad_source_0_0, '0', blocks_stream_mux_0, '1']
- [vocoder_ulaw_encode_sb_0, '0', pad_sink_0, '0']

metadata:
  file_format: 1
