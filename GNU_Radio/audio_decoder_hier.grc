options:
  parameters:
    generate_options: hb
    id: audio_decoder
    output_language: python
    title: Audio Decoder Hier
  states: {}

blocks:
- name: scale
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: scale
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1, 1)
    type: float
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: audio_out_0
    type: float
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: audio_out_1
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in
    type: byte
  states: {}
- name: vocoder_ulaw_decode_bs_0
  id: vocoder_ulaw_decode_bs
  parameters: {}
  states: {}

connections:
- [blocks_short_to_float_0, '0', blocks_stream_demux_0, '0']
- [blocks_stream_demux_0, '0', pad_sink_0_0, '0']
- [blocks_stream_demux_0, '1', pad_sink_0, '0']
- [pad_source_0, '0', vocoder_ulaw_decode_bs_0, '0']
- [vocoder_ulaw_decode_bs_0, '0', blocks_short_to_float_0, '0']

metadata:
  file_format: 1
