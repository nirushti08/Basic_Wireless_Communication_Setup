options:
  parameters:
    generate_options: hb
    id: transmitter
    output_language: python
    title: Transmitter
  states: {}

blocks:
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[+0.7071+0.7071j, -0.7071+0.7071j, +0.7071-0.7071j, -0.7071-0.7071j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_matrix_interleaver_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '1'
    deint: 'False'
    rows: '1'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_scrambler_bb_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: tx_out
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: tx_in
    type: byte
  states: {}

connections:
- [blocks_matrix_interleaver_0, '0', digital_constellation_modulator_0, '0']
- [blocks_pack_k_bits_bb_0_0, '0', blocks_matrix_interleaver_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_scrambler_bb_0, '0']
- [blocks_throttle_0, '0', pad_sink_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle_0, '0']
- [digital_scrambler_bb_0, '0', blocks_pack_k_bits_bb_0_0, '0']
- [pad_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']

metadata:
  file_format: 1
