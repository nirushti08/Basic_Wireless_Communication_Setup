options:
  parameters:
    author: gurrutchalla
    generate_options: no_gui
    id: assembled7
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 3e9
  states: {}
- name: max_noise
  id: variable
  parameters:
    value: '.584'
  states: {}
- name: rf_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32e3*3
  states: {}
- name: taps
  id: variable
  parameters:
    value: '[1.0, 0.25-0.25j, 0.50 + 0.10j, -0.3 + 0.2j]'
  states: {}
- name: audio_decoder_0
  id: audio_decoder
  parameters: {}
  states: {state: disabled}
- name: audio_encoder_0
  id: audio_encoder
  parameters: {}
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {state: disabled}
- name: audio_source_0
  id: audio_source
  parameters:
    num_outputs: '2'
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/gurrutchalla/Documents/Octave/recieved3.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/gurrutchalla/Documents/Octave/recieved2.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /home/gurrutchalla/Documents/Octave/recieved1.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gurrutchalla/Documents/Octave/image_bin3.txt
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/gurrutchalla/Documents/Octave/image_bin2.txt
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/gurrutchalla/Documents/Octave/image_bin1.txt
    repeat: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.8'
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    comment: |-
      For debugging 
      purposes
    name: data
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    comment: |-
      For debugging 
      purposes
    name: data
    type: complex
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: /home/gurrutchalla/Documents/GNURadio/output_audio.wav
    format: FORMAT_WAV
    nchan: '2'
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/gurrutchalla/Music/MunAndhi.wav
    nchan: '2'
    repeat: 'False'
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.00005'
    freq_offset: '1e-4'
    noise_voltage: '.483'
    seed: '0'
    taps: taps
  states: {}
- name: note_0
  id: note
  parameters:
    alias: Help
    comment: |-
      To send RGB images Enable a FILE SOURCE block and  
      coresponding FILE SINK block(Select block and press E) and 
      Disable others (Select block and press D) and execute the flow 
      graph, and repeat this for each 3 pair of FILE SOURCE , FILE SINK 
      blocks.

      To send Mono images do this only for the first pair of blocks.

      After this run ocatave code for recreate the image. :D

      To send live audio select Enable AUDIO ENCODER HIER block,
      AUDIO DECODER HIER block, AUDIO SOURCE block, AGC block 
      and AUDIO SINK and/or WAV FILE SINK (if you want to record 
      audio), while Disabling all other input output blocks.

      To send an audio .wav file Enable AUDIO ENCODER HIER block,
      AUDIO DECODER HIER block, WAV FILE SOURCE block 
      AUDIO SINK and/or WAV FILE SINK (if you want to record 
      audio), while Disabling all other input output blocks.
    note: Help
  states: {state: disabled}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: bladerf=0
    bb_gain0: '-18'
    bw0: rf_rate
    freq0: center_freq
    gain0: '10'
    if_gain0: '0'
    sample_rate: rf_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: bladerf=0
    bb_gain0: '20'
    bw0: rf_rate
    freq0: center_freq
    gain0: '6'
    gain_mode0: 'False'
    if_gain0: '0'
    sample_rate: rf_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '56832000'
    fbw: '0.4'
    interp: '1000000'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000000'
    fbw: '0.4'
    interp: '96000'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '1000000'
    fbw: '0.4'
    interp: '96000'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_1
  id: rational_resampler_xxx
  parameters:
    decim: '96000'
    fbw: '0.4'
    interp: '1000000'
    type: ccc
  states: {state: disabled}
- name: reciever_hier_0
  id: reciever_hier
  parameters: {}
  states: {}
- name: transmitter_hier_0
  id: transmitter_hier
  parameters: {}
  states: {}

connections:
- [audio_decoder_0, '0', audio_sink_0, '0']
- [audio_decoder_0, '0', blocks_wavfile_sink_0, '0']
- [audio_decoder_0, '1', audio_sink_0, '1']
- [audio_decoder_0, '1', blocks_wavfile_sink_0, '1']
- [audio_encoder_0, '0', blocks_throttle_0, '0']
- [audio_source_0, '0', audio_encoder_0, '0']
- [audio_source_0, '1', audio_encoder_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0, '0', blocks_throttle_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_throttle_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', osmosdr_sink_0, '0']
- [blocks_throttle_0, '0', transmitter_hier_0, '0']
- [blocks_wavfile_source_0, '0', audio_encoder_0, '0']
- [blocks_wavfile_source_0, '1', audio_encoder_0, '1']
- [channels_channel_model_0, '0', reciever_hier_0, '0']
- [osmosdr_source_0, '0', rational_resampler_xxx_0_0_0, '0']
- [rational_resampler_xxx_0_0_0, '0', reciever_hier_0, '0']
- [rational_resampler_xxx_0_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [reciever_hier_0, '0', audio_decoder_0, '0']
- [reciever_hier_0, '0', blocks_file_sink_0, '0']
- [reciever_hier_0, '0', blocks_file_sink_0_0, '0']
- [reciever_hier_0, '0', blocks_file_sink_0_0_0, '0']
- [reciever_hier_0, '0', blocks_tag_debug_0, '0']
- [transmitter_hier_0, '0', blocks_tag_debug_0_0, '0']
- [transmitter_hier_0, '0', channels_channel_model_0, '0']
- [transmitter_hier_0, '0', rational_resampler_xxx_0_1, '0']

metadata:
  file_format: 1
