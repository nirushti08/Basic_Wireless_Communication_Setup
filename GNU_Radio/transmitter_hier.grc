options:
  parameters:
    generate_options: hb
    id: transmitter_hier
    output_language: python
    title: Transmitter Block
  states: {}

blocks:
- name: enc_cc
  id: variable_cc_encoder_def
  parameters:
    framebits: 12000*2
    k: '7'
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'True'
    polys: '[109,79]'
    rate: '2'
    state_start: '0'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: len_key
  id: variable
  parameters:
    value: '"packet length"'
  states: {}
- name: message_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[+0.7071+0.7071j, -0.7071+0.7071j, +0.7071-0.7071j, -0.7071-0.7071j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_matrix_interleaver_0
  id: blocks_matrix_interleaver
  parameters:
    cols: '4'
    deint: 'False'
    rows: '4'
    type: byte
    vlen: '16'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_2_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_pack_k_bits_bb_0_0_2_1_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_key
    packet_len: message_size
    type: byte
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 96e3
    type: byte
  states: {state: disabled}
- name: blocks_unpack_k_bits_bb_0_1_1_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_0_1_1_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '16'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_scrambler_bb_0_0
  id: digital_scrambler_bb
  parameters:
    len: '7'
    mask: '0x8A'
    seed: '0x7F'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):
          """Packet Format"""

          def __init__(self):
              gr.sync_block.__init__(self,
                  name = "Packet Format",
                  in_sig=None,
                  out_sig = None)
              self.message_port_register_in(pmt.intern('PDU_in'))
              self.message_port_register_out(pmt.intern('PDU_out'))
              self.set_msg_handler(pmt.intern('PDU_in'), self.handle_msg)

          def handle_msg(self,msg):
              inMsg = pmt.to_python (msg)
              pld = inMsg[1]
              # print (pld)
              mLen = len(pld)
              # print (mLen)
              if (mLen > 0):
                  char_list = [85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,225,90,232,147]
                  char_list.append (mLen >> 8)
                  char_list.append (mLen & 255)
                  char_list.append (mLen >> 8)
                  char_list.append (mLen & 255)
                  char_list.extend (pld)
                  #char_list.extend ([85,85,85,85,85,85,85,85,85,85,85,85,85,85,85,85])
                  # print (char_list)
                  out_len = len(char_list)
                  # print (out_len)
                  #output_items[0][:] = char_list
                  self.message_port_pub(pmt.intern('PDU_out'), pmt.cons(pmt.PMT_NIL,pmt.init_u8vector(out_len,(char_list))))
  states: {}
- name: fec_extended_encoder_0
  id: fec_extended_encoder
  parameters:
    encoder_list: enc_cc
    puncpat: '''11'''
    threadtype: none
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: to_tx
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: data_in
    type: byte
  states: {}
- name: pdu_pdu_to_tagged_stream_0
  id: pdu_pdu_to_tagged_stream
  parameters:
    tag: len_key
    type: byte
  states: {}
- name: pdu_tagged_stream_to_pdu_0_1
  id: pdu_tagged_stream_to_pdu
  parameters:
    tag: len_key
    type: byte
  states: {}

connections:
- [blocks_matrix_interleaver_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_pack_k_bits_bb_0_0_2_1, '0', blocks_stream_to_vector_0, '0']
- [blocks_pack_k_bits_bb_0_0_2_1_0, '0', digital_constellation_modulator_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', pdu_tagged_stream_to_pdu_0_1, '0']
- [blocks_stream_to_vector_0, '0', blocks_matrix_interleaver_0, '0']
- [blocks_throttle_0, '0', blocks_unpack_k_bits_bb_0_1_1_0_0, '0']
- [blocks_unpack_k_bits_bb_0_1_1_0_0, '0', fec_extended_encoder_0, '0']
- [blocks_unpack_k_bits_bb_0_1_1_0_0_0, '0', digital_scrambler_bb_0_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [digital_constellation_modulator_0, '0', pad_sink_0, '0']
- [digital_scrambler_bb_0_0, '0', blocks_pack_k_bits_bb_0_0_2_1_0, '0']
- [epy_block_0, PDU_out, pdu_pdu_to_tagged_stream_0, pdus]
- [fec_extended_encoder_0, '0', blocks_pack_k_bits_bb_0_0_2_1, '0']
- [pad_source_0, '0', blocks_throttle_0, '0']
- [pad_source_0, '0', blocks_unpack_k_bits_bb_0_1_1_0_0, '0']
- [pdu_pdu_to_tagged_stream_0, '0', blocks_unpack_k_bits_bb_0_1_1_0_0_0, '0']
- [pdu_tagged_stream_to_pdu_0_1, pdus, epy_block_0, PDU_in]

metadata:
  file_format: 1
